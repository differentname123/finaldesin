# Keil uVision project ADC_0832.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000) MODA2
  output: ADC_0832 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
